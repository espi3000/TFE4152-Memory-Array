[aimspice]
[description]
545
*******************************************
* INCLUDES
*******************************************
.include gpdk90nm_tt.cir
.include not.cir

*******************************************
* VOLTAGE SOURCE
*******************************************
vdd1 vdd 0 vh
vdd2 vss 0 0

*******************************************
* STIMULI
*******************************************
vin in vss
vref ref vss 0.225

*******************************************
* DUT
*******************************************
xnot out in vdd vss not

[options]
0
[dc]
1
vin
0
0.45
0.001
[tran]
0.001fs
160ps
X
X
0
[ana]
1 1
0
1 1
1 1 0 0.5
2
v(ref)
v(out)
[end]
