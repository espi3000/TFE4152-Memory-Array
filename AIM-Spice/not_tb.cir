[aimspice]
[description]
542
*******************************************
* INCLUDES
*******************************************
.include gpdk90nm_ff.cir
.include not.cir

*******************************************
* VOLTAGE SOURCE
*******************************************
vdd1 vdd 0 1
vdd2 vss 0 0

*******************************************
* STIMULI
*******************************************
vin in vss
vref ref vss 0.5

*******************************************
* DUT
*******************************************
xnot out in vdd vss not

[dc]
1
vin
0
1
0.001
[tran]
0.001fs
160ps
X
X
0
[ana]
1 1
0
1 1
1 1 0 1
2
v(ref)
v(out)
[end]
