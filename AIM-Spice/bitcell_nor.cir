[aimspice]
[description]
1110
*******************************************
* INCLUDES
*******************************************
.include gpdk90nm_ss.cir
.include nand.cir
.include nor.cir
.include not.cir

*******************************************
* VOLTAGE SOURCE
*******************************************
vdd1 vdd 0 vh
vdd2 vss 0 0

*******************************************
* STIMULI
*******************************************
vsel sel vss pulse(vh 0 1ps 1ps 1ps 20ns 20ns)
vrw rw vss pulse(0 vh 1ps 1ps 1ps 5ns 10ns)
vin in vss pulse(0 vh 1ps 1ps 1ps 10ns 20ns)

*******************************************
* SR LATCH
*******************************************
xnandq q s notq vdd vss 2_in_nand
xnandnotq notq r q vdd vss 2_in_nand

*******************************************
* INPUT SELECT
*******************************************
xnot notsel sel vdd vss not
xnands s in notsel rw vdd vss 3_in_nand
xnandr r s notsel rw vdd vss 3_in_nand

*******************************************
* OUTPUT SELECT
*******************************************
xnorout out notq sel rw vdd vss 3_in_nor
[options]
2
Tnom 100
Temp 100
[tran]
0.0001ps
12ns
3.5ns
1ps
0
[ana]
4 1
0
1 1
1 1 -0.1 0.5
1
v(out)
[end]
