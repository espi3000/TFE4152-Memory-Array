[aimspice]
[description]
1114
*******************************************
* INCLUDES
*******************************************
.include gpdk90nm_tt.cir
.include nand.cir
.include nor.cir
.include not.cir

*******************************************
* VOLTAGE SOURCE
*******************************************
vdd1 vdd 0 1
vdd2 vss 0 0

*******************************************
* STIMULI
*******************************************
vsel sel vss pulse(0 1 0ns 1ps 1ps 400ns 400ns)
vrw rw vss pulse(0 1 0ns 1ps 1ps 100ns 200ns)
vin in vss pulse(0 1 0ns 1ps 1ps 200ns 400ns)

*******************************************
* SR LATCH
*******************************************
xnandq q s notq vdd vss 2_in_nand
xnandnotq notq r q vdd vss 2_in_nand

*******************************************
* INPUT SELECT
*******************************************
xnands s in sel rw vdd vss 3_in_nand
xnandr r s sel rw vdd vss 3_in_nand

*******************************************
* OUTPUT SELECT
*******************************************
xnot notsel sel vdd vss not
xnorout out notq notsel rw vdd vss 3_in_nor
[tran]
0.000001ns
400ns
X
X
0
[ana]
4 2
0
1 1
1 1 -0.1 1.5
1
v(out)
0
1 1
1 1 -0.1 1.5
3
v(sel)
v(rw)
v(in)
[end]
