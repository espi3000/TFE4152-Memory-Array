[aimspice]
[description]
1121
*******************************************
* INCLUDES
*******************************************
.include gpdk90nm_tt.cir
.include nand.cir
.include nor.cir
.include not.cir

*******************************************
* VOLTAGE SOURCE
*******************************************
vdd1 vdd 0 1
vdd2 vss 0 0

*******************************************
* STIMULI
*******************************************
vsel sel vss pulse(1 0 0ps 0ps 0ps 4000ps 4000ps)
vrw rw vss pulse(0 1 0ps 0ps 0ps 1000ps 2000ps)
vin in vss pulse(0 1 0ps 0ps 0ps 2000ps 4000ps)

*******************************************
* SR LATCH
*******************************************
xnandq q s notq vdd vss 2_in_nand
xnandnotq notq r q vdd vss 2_in_nand

*******************************************
* INPUT SELECT
*******************************************
xnot notsel sel vdd vss not
xnands s in notsel rw vdd vss 3_in_nand
xnandr r s notsel rw vdd vss 3_in_nand

*******************************************
* OUTPUT SELECT
*******************************************
xnorout out notq sel rw vdd vss 3_in_nor

[tran]
0.00001ps
4000ps
X
X
0
[ana]
4 2
0
1 1
1 1 -0.184768 1.13974
1
v(out)
0
1 1
1 1 -0.0523179 1.03907
3
v(sel)
v(rw)
v(in)
[end]
